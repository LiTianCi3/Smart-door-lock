# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver;.\Lib;.\OLED;.\User
  group User
    ./User/: main.c
  group Driver
    ./Driver/: MatrixKeys.c FPM383C.c Ultrasonic.c
  group Lib
    ./Lib/: Delay.c EEPROM.c GPIO.c STC8H_PWM.c STC8H_PWM_Isr.c NVIC.c UART.c UART_Isr.c
    ./OLED/: oled.c
